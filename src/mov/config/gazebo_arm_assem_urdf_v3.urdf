Commit message: modify mov

File: src/mov/config/gazebo_arm_assem_urdf_v3.urdf (robot description, URDF)
Before this commit: robot arm_assem_urdf_v3, 11 links, 10 joints
Joints:
- joint r_fingerj: axis 0 0 0 -> 0 0 -1
